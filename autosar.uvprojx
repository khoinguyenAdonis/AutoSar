# Keil uVision project autosar.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: autosar
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__GNUC__
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: main.c stm32f4xx_it.c system_stm32f4xx.c Dio.c Spi.c
  group inc
    ./inc/: main.h stm32f4xx_conf.h stm32f4xx_it.h Dio.h Spi.h
  group stdlib
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
  group startup
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
